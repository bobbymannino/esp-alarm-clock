## sdkconfig.defaults
```kconfig
CONFIG_SPI_FLASH_SUPPORT_BOYA_CHIP=y

CONFIG_LOG_MAXIMUM_LEVEL_DEBUG=y
CONFIG_LOG_DEFAULT_LEVEL_DEBUG=y
```
